<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\U_I_P.ewp</path>
  </project>
  <batchBuild />
</workspace>
